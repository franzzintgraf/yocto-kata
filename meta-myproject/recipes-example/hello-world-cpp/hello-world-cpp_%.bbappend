FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Change-greeting-message-for-the-yocto-kata.patch"


FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://cve-2021-3640.patch"
